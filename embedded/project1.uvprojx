# Keil uVision project project1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.9.0
  cpu: IRAM(0x1FFF8000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  group Source Group 1
    ./: main.c
software components: RTOS:Config 10.2.0, RTOS:Core 10.2.0, RTOS:Heap 10.2.0, RTOS:Timers 10.2.0, CMSIS:CORE 5.2.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.0.0
